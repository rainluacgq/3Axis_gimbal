# Keil uVision project gimbal.uvprojx, settings and files
target gimbal (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MPU6050 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\MPU6050;..\USMART;..\HARDWARE\BOARDMPU;..\SYSTEM;..\HARDWARE\motor;..\HARDWARE\REPORT;..\HARDWARE\AS14TTL;..\HARDWARE\USART3;..\HARDWARE\MAG3110
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c gimbalcontrol.c kalman.c
  group HARDWARE
    ./: pid.c report.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/MPU6050/: mpu6050.c mpui2c.c
    ../HARDWARE/BOARDMPU/: boardmpu.c boardmpui2c.c
    ../HARDWARE/motor/: motor.c
    ../HARDWARE/AS14TTL/: as14ttl.c
    ../HARDWARE/REPORT/: tim5message.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/MAG3110/: mag3110.c magi2c.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c
  group README
    ../: README.TXT
